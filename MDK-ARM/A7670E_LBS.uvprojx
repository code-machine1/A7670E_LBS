# Keil uVision project A7670E_LBS.uvprojx, settings and files
target A7670E_LBS (6180000::V6.18::ARMCLANG)
  device: STM32L010K4Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x200007FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: A7670E_LBS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 v6Lto=1 wLevel=4
  c define: STM32L010x4,USE_HAL_DRIVER
  c misc: -Wno-compare-distinct-pointer-types
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../gmsi;../gmsi/utilities;../gmsi/component;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../gmsi/utilities/PLOOC;../class;../peripheral;../app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Application/MDK-ARM
    ./: startup_stm32l010x4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c rtc.c tim.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group class
    ../class/: battery.c positionmodule.c steppermotor.c
  group app
    ../app/: bq27220.c
software components: CMSIS:CORE 5.6.0
